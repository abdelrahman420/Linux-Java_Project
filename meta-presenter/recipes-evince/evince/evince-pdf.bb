SUMMARY = "Evince - A document viewer for multiple document formats like PDF and Postscript"
DESCRIPTION = "Evince is a document viewer for multiple document formats such as PDF, Postscript, djvu, tiff, dvi, XPS, and more."
HOMEPAGE = "https://wiki.gnome.org/Apps/Evince"


IMAGE_INSTALL:append = " evince"
